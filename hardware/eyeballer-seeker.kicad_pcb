# Repository aquaNeosIN/eyeballer-seeker

File README.md:

# eyeballer-seeker

A wrist-worn screen with anime eyes that follow people walking by.

Sit with the face turned outward. Someone crosses in front of the camera and the eyes lock on; they leave, and the eyes drift back to the middle. From the side it still looks like the face is looking at you. That is the Mona Lisa effect. The person wearing it is behind the camera. A shape that fills the frame is ignored.

This tree is the **v2** prototype: an Alientek DNESP32S3 board, a kit OV5640 camera, and a Waveshare 1.69″ touch LCD. The eyes follow motion. They do not yet recognize a face.

## Versions

v1 and v2 are different machines. They do not share a display bus or a sensor.

| | v1 | v2 (this tree) |
| --- | --- | --- |
| Board | Waveshare ESP32-S3 Touch AMOLED 1.75 | 正点原子 DNESP32S3 (ESP32-S3) |
| Display | 1.75″ round, QSPI, CO5300, about 466×466 | Waveshare 1.69″, 240×280, ST7789V2, 4-wire SPI |
| Sensing | HLK-LD2450 24 GHz radar, up to 3 targets | Kit OV5640 on the board DVP connector. Motion, then the center of the strongest cluster |
| Other parts | QMI8658 IMU, 5V boost for the radar, a small carrier PCB | None of those. Breadboard wires are enough |
| Firmware | `firmware/` on the v1 branch | `firmware/` in this tree |
| Where to read it | Draft pull request [#1](https://github.com/aquaNeosIN/eyeballer-seeker/pull/1), branch `cursor/hardware-schematic-2838` | This branch |

v1 is still the radar-and-round-screen design. Opening or merging this v2 tree does not change that pull request. A longer note is in [docs/VERSIONS.md](docs/VERSIONS.md).

## How v2 watches

1. The camera task grabs an RGB565 frame (QVGA by default) and keeps a coarse luma image, about 80×60.
2. Pixels that changed since the previous frame are grouped into a 10×8 grid. The strongest cluster becomes one target. A change smaller than 2% of the frame is noise. A change larger than 40% of the frame is treated as too close and dropped.
3. The eye task smooths that point, holds it for about 1.5 s after it disappears, then lets the pupils drift home and glance around. The pupils also blink.
4. The display task draws two eyes into a circular dial on the 240×280 panel and flushes the eye band over SPI.

There is no face detector, no radar, and no wrist IMU in this version. A person who stops moving is held for the linger time and then released. A later tracker can replace the motion step without changing the eye drawing. Thresholds live in `firmware/main/config.h`. The face itself is `k_face` in `firmware/main/face.h`.

The panel is a rounded rectangle, not a round GC9A01. The firmware paints a black circular mask (diameter 232, centered on the glass) so the eyes sit in a watch-like window. Details are in [hardware/v2-dnesp32s3-camera/README.md](hardware/v2-dnesp32s3-camera/README.md).

## Hardware

| Part | Role |
| --- | --- |
| [正点原子 DNESP32S3](https://www.alientek.com/Product_Details_12/28.html) | ESP32-S3, USB, XL9555 expander, DVP camera socket, SPI LCD socket |
| Kit OV5640 | Plugs into connector P2. SCCB and 8-bit DVP. Reset and power-down are on the XL9555 |
| [Waveshare 1.69″ Touch LCD](https://www.waveshare.com/wiki/1.69inch_Touch_LCD_Module) | ST7789V2 over SPI, 240×280. CST816T touch is on the module and is not read yet |

Wiring, the P5 `IO_SET`–`LCD_DC` jumper, and the pin table are in [hardware/v2-dnesp32s3-camera/README.md](hardware/v2-dnesp32s3-camera/README.md). v1 drawings stay on the v1 branch; [hardware/v1-radar-amoled/README.md](hardware/v1-radar-amoled/README.md) is only a pointer.

## Firmware

ESP-IDF and FreeRTOS, target `esp32s3`. Three tasks:

| Task | Core | Work |
| --- | ---: | --- |
| `cam` | 0 | Capture, or a synthetic walker when `SIMULATE_CAMERA` is 1 |
| `eye` | 0 | Pick the look point, smooth it, blink |
| `disp` | 1 | Draw the face and blit it to the ST7789 |

Install and flash steps are in [firmware/README.md](firmware/README.md). The v1 firmware is not copied into this tree. [firmware-v1-radar/README.md](firmware-v1-radar/README.md) says where it lives.

```bash
cd firmware
idf.py set-target esp32s3
idf.py build
idf.py -p PORT flash monitor
```

`SIMULATE_CAMERA` defaults to 0, so a normal build opens the OV5640. Set it to 1 for a first look at the eyes with no sensor.

## Layout

```text
.
├── firmware/                         v2 ESP-IDF project (the default build)
│   ├── main/
│   ├── test/                         host test for motion and gaze
│   └── README.md
├── firmware-v1-radar/                pointer to the v1 firmware branch
├── hardware/
│   ├── v1-radar-amoled/              pointer to the v1 schematic and PCB
│   └── v2-dnesp32s3-camera/          v2 wiring
├── docs/VERSIONS.md
├── LICENSE
└── README.md
```

## License

[MIT](LICENSE).

## KiCad design hardware/eyeballer-seeker.kicad_pcb

File hardware/README.md:

# Hardware

Two stacks. Pick the folder that matches the board in your hand.

| Folder | Stack |
| --- | --- |
| [v1-radar-amoled](v1-radar-amoled/README.md) | Waveshare 1.75″ round AMOLED, HLK-LD2450, boost, carrier PCB. Files live on the v1 branch |
| [v2-dnesp32s3-camera](v2-dnesp32s3-camera/README.md) | DNESP32S3, kit OV5640, Waveshare 1.69″ SPI LCD. Wiring for this tree |

Parts:
BT1: Li-ion 3.7V
C1, C4: 100nF; C_0805_2012Metric
C2: 22uF; C_0805_2012Metric
C3: 100uF; C_1206_3216Metric
J1: MX1.25; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J2: to board J1; PinHeader_1x02_P2.54mm_Vertical
J3: TPS61023 module; PinHeader_1x04_P2.54mm_Vertical
J4: HLK-LD2450; PinHeader_1x04_P2.54mm_Vertical
J5: to H2; PinHeader_1x08_P2.54mm_Vertical
R1, R2: 220; R_0805_2012Metric
SW1: SPDT; SW_SPDT_CK_JS102011SAQN

Connections:
+5V_RADAR: C3.1, C4.1, J3.4, J4.1
/BOOST_IN: C1.1, C2.1, J3.1, J3.3, SW1.1 (A)
/RADAR_RX: J5.7, R1.2
/RADAR_TX: J5.8, R2.2
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, J1.2, J2.2, J3.2, J4.2, J5.2
unnamed: J4.3, R2.1
unnamed: J4.4, R1.1
VBAT: BT1.1 (+), J1.1, J2.1, SW1.2 (B)

Notes on the sheet:
Battery and switch
电池正极是 VBAT。开关脚 2 是公共端，只给升压；脚 3 不接。
Battery connector J1
J1 接电池。J2 接到开发板电池座，和板内充电并联。
5V boost TPS61023
脚序 1 VIN、2 GND、3 EN、4 VOUT，以模块实物为准。EN 与 VIN 同网。
Radar HLK-LD2450
脚序 1=5V 2=GND 3=TX 4=RX。PA9 不接。串口 3.3V，各串 220Ω。
ESP32-S3 board header H2
排针脚序来自 Waveshare 原理图 PDF（2025-07-28）。
同名网络是连在一起的：VBAT、GND、+5V_RADAR、BOOST_IN、RADAR_TX、RADAR_RX。
RADAR_TX：雷达 TX 到 H2 脚 8。RADAR_RX：H2 脚 7 到雷达 RX。焊前用万用表核对脚序和电池正负。
1 5V
2 GND
3 TX
4 RX
1 VBUS
3 VCC3V3
4 U0TXD GPIO43
5 U0RXD GPIO44
6 GPIO16
7 GPIO17 radar RX
8 GPIO18 radar TX

Board: 2 copper layers, 40.0 x 36.0 mm, 12 parts (0 on the bottom side), 8 nets.
